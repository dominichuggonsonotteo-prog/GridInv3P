# Keil uVision project MassStorage.uvprojx, settings and files
target Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F303VETx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0-RC1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MassStorage
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source
    ./: MassStorage.c USBD_User_MSC_0.c
  group Documentation
    ./: Abstract.txt
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F303VETx/STCubeGenerated/Src/: main.c stm32f3xx_it.c
    ./RTE/Device/STM32F303VETx/STCubeGenerated/Inc/: stm32f3xx_it.h
target Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F303VETx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0-RC1
  cpu: as above
  output: MassStorage
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 5.0.2, CMSIS:RTOS2:Keil RTX5 5.2.3, Compiler:I/O:File 1.2.1, Device:STM32Cube HAL 1.9.0, File System:CORE 6.10.0, File System:Drive:Memory Card 6.10.0, USB:CORE 6.12.0, USB:Device 6.12.0, USB:Device:MSC 6.12.0, CMSIS Driver:SPI 1.0.0, CMSIS Driver:USB Device 1.0.0
