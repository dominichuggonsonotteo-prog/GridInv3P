# Keil uVision project inv3p.uvprojx, settings and files
target inv3p (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F334R8Tx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.3.0.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00004000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: inv3p +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F334x8,
  c misc: --C99
  c include: ..\Lib\CMSIS\Device\ST\STM32F30x\Include;..\Lib\CMSIS\Include;..\Lib\STM32F30x_StdPeriph_Driver\inc;..\Lib\STM32F30x_StdPeriph_Driver\src;..\MDK_ARM;..\Algorithm;..\Integration;..\Sys_code;..\User_code\Driver;..\User_code\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x10000000 size 0x1000
  scatter file: ..\Lib\STM32F334C8T6.sct
  link misc: --diag_suppress=L6329
  group Lib
    ./: startup_stm32f334x8.s
    ../Lib/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_hrtim.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
  group Sys_code
    ../Sys_code/: sys_timer.c system_stm32f30x.c
  group Driver
    ../User_code/Driver/: adc.c comp.c dac.c gpio.c hrtimer.c iwdg.c nvic.c timer.c uart.c
  group App
    ../User_code/App/: idle.c irq.c main.c oled.c protect.c sample.c inv3p.c math.c
